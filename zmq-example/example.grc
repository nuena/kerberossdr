options:
  parameters:
    generate_options: qt_gui
    id: example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: b2f2_0_0_0
  id: b2f2
  parameters: {}
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: BW
    fc: '0'
    fftsize: '1024'
    int_min: '-80'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: BW
    fc: '0'
    fftsize: '1024'
    int_min: '-80'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: BW
    fc: '0'
    fftsize: '1024'
    int_min: '-80'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: BW
    fc: '0'
    fftsize: '1024'
    int_min: '-80'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:9876
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:9900
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [b2f2_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_deinterleave_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_deinterleave_0, '2', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_deinterleave_0, '3', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0_0_0_0, '0', b2f2_0_0_0, '0']

metadata:
  file_format: 1
